FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://tqma8mpxl.cfg"
SRC_URI += "file://0001-include-configs-tqma8mpxl-Increase-maximum-bootm-siz.patch"
