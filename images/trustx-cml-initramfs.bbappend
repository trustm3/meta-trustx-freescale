PACKAGE_INSTALL:tqma8mpxl += "bootloader-loopdev"
