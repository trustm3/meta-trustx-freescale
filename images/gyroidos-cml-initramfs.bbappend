PACKAGE_INSTALL:append:tqma8mpxl = " bootloader-loopdev"
