FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Added-missing-include-for-elv_register_queue-in-MD-d.patch"

